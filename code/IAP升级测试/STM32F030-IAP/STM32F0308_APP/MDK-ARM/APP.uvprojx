# Keil uVision project APP.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\OBJ\app.bin ..\OBJ\app.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: ..\Libraries\STM32F0xx_StdPeriph_Driver\src;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\MDK-ARM;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\CMSIS\Device\ST\STM32F0xx\Source;..\BSP;..\USER;..\HARDWARE;..\IAP
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  group Application/User
    ../USER/: main.c stm32f0xx_it.c system_stm32f0xx.c common.h stm32f0xx_conf.h
  group Application/Bsp
    ../BSP/: led.c systick.c time.c usart.c gpio.c iwdg.c adc.c exit.c rtc.c delay.c
  group IAP
    ../IAP/: crc8_16.c softtimer.c
  group STM32F0xx_StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_misc.c stm32f0xx_dma.c stm32f0xx_usart.c stm32f0xx_spi.c stm32f0xx_flash.c stm32f0xx_iwdg.c stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_i2c.c stm32f0xx_rtc.c stm32f0xx_wwdg.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x8.s
software components: CMSIS:CORE 5.0.0
