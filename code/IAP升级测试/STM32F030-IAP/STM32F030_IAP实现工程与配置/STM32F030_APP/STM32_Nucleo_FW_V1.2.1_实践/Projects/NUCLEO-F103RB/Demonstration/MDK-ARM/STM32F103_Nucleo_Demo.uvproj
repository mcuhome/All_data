# Keil uVision project STM32F103_Nucleo_Demo.uvproj, settings and files
target STM32F103_Nucleo_Demo (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_Nucleo_Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,
  c misc: --C99
  c include: ..\;..\..\;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_Nucleo\stm32f1xx;..\..\..\..\Utilities\STM32_Nucleo\adafruit;..\..\..\..\Utilities\\Common;..\..\..\..\Utilities\Third_Party\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_NUCLEO
    ../../../../Utilities/STM32_Nucleo/adafruit/: stm32_adafruit_spi_lcd.c stm32_adafruit_spi_usd.c
    ../../../../Utilities/STM32_Nucleo/stm32f1xx/: stm32f1xx_nucleo.c
  group User
    ../../../../Utilities/Common/: fonts.c
    ../../../../Utilities/Third_Party/FatFs/src/: ff.c
    ../: fatfs_drv.c fatfs_storage.c main.c stm32f1xx_it.c system_stm32f10x.c
