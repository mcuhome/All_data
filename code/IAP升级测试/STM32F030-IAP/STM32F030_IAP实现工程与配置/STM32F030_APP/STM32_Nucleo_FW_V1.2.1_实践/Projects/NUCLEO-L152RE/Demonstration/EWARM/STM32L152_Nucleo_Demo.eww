<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32L152_Nucleo_Demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


