# Keil uVision project STM32L152_Nucleo_Demo.uvproj, settings and files
target STM32L152_Nucleo_Demo (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152_Nucleo_Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_XL,
  c misc: --C99
  c include: ..\;..\..\;..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_Nucleo\stm32l1xx;..\..\..\..\Utilities\STM32_Nucleo\adafruit;..\..\..\..\Utilities\Common;..\..\..\..\Utilities\Third_Party\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_xl.s
  group STM32L1xx_StdPeriph_Driver
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group STM32_NUCLEO
    ../../../../Utilities/STM32_Nucleo/adafruit/: stm32_adafruit_spi_lcd.c stm32_adafruit_spi_usd.c
    ../../../../Utilities/STM32_Nucleo/stm32l1xx/: stm32l1xx_nucleo.c
  group User
    ../../../../Utilities/Common/: fonts.c
    ../../../../Utilities/Third_Party/FatFs/src/: ff.c
    ../: fatfs_drv.c fatfs_storage.c main.c stm32l1xx_it.c system_stm32l1xx.c
