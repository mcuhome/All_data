# IAR project STM32L152_Nucleo_Demo.ewp, settings and files
configuration STM32L152_Nucleo_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xE ST STM32L152xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_XL
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_Nucleo\stm32l1xx; ..\..\..\..\Utilities\STM32_Nucleo\adafruit; ..\..\..\..\Utilities\Common; ..\..\..\..\Utilities\Third_Party\FatFs\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L152_Nucleo_Demo.hex
  ILINK.IlinkOutputFile: STM32L152_Nucleo_Demo.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_xl.s
  group STM32_NUCLEO
    ../../../../Utilities/STM32_Nucleo/adafruit/: stm32_adafruit_spi_lcd.c stm32_adafruit_spi_usd.c
    ../../../../Utilities/STM32_Nucleo/stm32l1xx/: stm32l1xx_nucleo.c
  group STM32L1xx_StdPeriph_Driver
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group User
    ../: fatfs_drv.c fatfs_storage.c main.c stm32l1xx_it.c system_stm32l1xx.c
    ../../../../Utilities/Third_Party/FatFs/src/: ff.c
    ../../../../Utilities/Common/: fonts.c
