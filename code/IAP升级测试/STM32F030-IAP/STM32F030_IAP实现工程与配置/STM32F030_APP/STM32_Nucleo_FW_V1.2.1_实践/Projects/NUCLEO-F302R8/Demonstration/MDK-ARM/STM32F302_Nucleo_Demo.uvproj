# Keil uVision project STM32F302_Nucleo_Demo.uvproj, settings and files
target STM32F302_Nucleo_Demo (ARM-ADS)
  device: STM32F302R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F302_Nucleo_Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F302x8,
  c misc: --C99
  c include: ..\;..\..\;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_Nucleo\stm32f3xx;..\..\..\..\Utilities\STM32_Nucleo\adafruit;..\..\..\..\Utilities\\Common;..\..\..\..\Utilities\Third_Party\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f302x8.s
  group STM32F30x_StdPeriph_Driver
    ../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group STM32_NUCLEO
    ../../../../Utilities/STM32_Nucleo/adafruit/: stm32_adafruit_spi_lcd.c stm32_adafruit_spi_usd.c
    ../../../../Utilities/STM32_Nucleo/stm32f3xx/: stm32f3xx_nucleo.c
  group User
    ../../../../Utilities/Common/: fonts.c
    ../../../../Utilities/Third_Party/FatFs/src/: ff.c
    ../: fatfs_drv.c fatfs_storage.c main.c stm32f3xx_it.c system_stm32f30x.c
