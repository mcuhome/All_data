# Keil uVision project STM32F030_Nucleo_Demo.uvproj, settings and files
target STM32F030_Nucleo_Demo (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F030_Nucleo_Demo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,
  c misc: --C99
  c include: ..\;..\..\;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_Nucleo\stm32f0xx;..\..\..\..\Utilities\STM32_Nucleo\adafruit;..\..\..\..\Utilities\Common;..\..\..\..\Utilities\Third_Party\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM32_NUCLEO
    ../../../../Utilities/STM32_Nucleo/adafruit/: stm32_adafruit_spi_lcd.c stm32_adafruit_spi_usd.c
    ../../../../Utilities/STM32_Nucleo/stm32f0xx/: stm32f0xx_nucleo.c
  group User
    ../../../../Utilities/Common/: fonts.c
    ../../../../Utilities/Third_Party/FatFs/src/: ff.c
    ../: fatfs_drv.c fatfs_storage.c main.c stm32f0xx_it.c system_stm32f0xx.c
