# IAR project STM32F030_Nucleo_Demo.ewp, settings and files
configuration STM32F030_Nucleo_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030
  ICCARM.CCIncludePath2: ..\; ..\..\; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_Nucleo\stm32f0xx; ..\..\..\..\Utilities\STM32_Nucleo\adafruit; ..\..\..\..\Utilities\Common; ..\..\..\..\Utilities\Third_Party\FatFs\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F030_Nucleo_Demo.hex
  ILINK.IlinkOutputFile: STM32F030_Nucleo_Demo.out
  ILINK.IlinkIcfFile: stm32f030_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030.s
  group STM32_NUCLEO
    ../../../../Utilities/STM32_Nucleo/adafruit/: stm32_adafruit_spi_lcd.c stm32_adafruit_spi_usd.c
    ../../../../Utilities/STM32_Nucleo/stm32f0xx/: stm32f0xx_nucleo.c
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../: fatfs_drv.c fatfs_storage.c main.c stm32f0xx_it.c system_stm32f0xx.c
    ../../../../Utilities/Third_Party/FatFs/src/: ff.c
    ../../../../Utilities/Common/: fonts.c
